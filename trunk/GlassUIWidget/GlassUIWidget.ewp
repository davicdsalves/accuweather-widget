# IAR project GlassUIWidget.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ../C++/: _cpp2.cpp
    ../include/: func.asm
    ./: main.cpp mybook.cpp
  group bcfg
    bcfg/: conf_loader.cpp config_data.c
  group debug and leaker
    ./: debug.cpp
    ../deleaker/: mem2.cpp
  group draw
    standby/: id3.cpp standbyDraw.cpp
  group file
    file/: fileAnaliser.cpp openfile.cpp
  group Utils
    utils/: Utils.cpp weather.cpp
